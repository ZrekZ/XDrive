# IAR project Backup of Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xB ST STM32F303xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; System\; Hardware\; Software\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: template_file.out
  ILINK.IlinkIcfFile: system\stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    system/: system.c system_stm32f3xx.c
  group Doc
    docs/: menu.txt pid_coeff.txt
    ./: readme.txt
  group EWARM
    system/: startup_stm32f303xc.s
  group HardWare
    Hardware/: adc.c crc.c dac.c dma.c hw_ctrl.c i2c.c IOs.c irq.c spi.c switches.c Timers.c usart.c
  group SoftWare
    Software/: indicator.c menu.c pi_reg.c transmission.c
  group User
    ./: main.c
